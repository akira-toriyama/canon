## boards/shields/imprint_dongle/Kconfig.defconfig
```kconfig
if SHIELD_IMPRINT_DONGLE

config ZMK_KEYBOARD_NAME
    default "Imprint Dongle"

config ZMK_USB
    default y

endif
```
